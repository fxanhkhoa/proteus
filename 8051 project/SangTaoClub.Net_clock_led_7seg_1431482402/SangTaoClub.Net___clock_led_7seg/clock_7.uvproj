# Keil uVision project clock_7.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: File_hex_clock_free +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: code_clock_ds1307.c
